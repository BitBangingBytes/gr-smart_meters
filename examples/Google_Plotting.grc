options:
  parameters:
    author: hash
    generate_options: no_gui
    id: google_plots
    output_language: python
    run_options: run
    title: Google Maps and Earth Example
  states: {}

blocks:
- name: sandia_utils_file_source_0
  id: sandia_utils_file_source
  parameters:
    begin_tag: pmt.PMT_NIL
    file: ./Test.dat
    file_tags: 'False'
    file_type: message
    force_new: 'False'
    msg_period_ms: '0'
    queue_depth: '100'
    rate: '0'
    repeat: 'False'
    type: complex
    vlen: '1'
  states: {}
- name: smart_meters_Deframer_0
  id: smart_meters_Deframer
  parameters:
    debug: 'False'
    max_length: '300'
    min_length: '6'
  states: {}
- name: smart_meters_GridStream_0
  id: smart_meters_GridStream
  parameters:
    baudrateEnable: 'True'
    crcEnable: 'True'
    crcInitialValue: '0x5FD6'
    debugEnable: 'True'
    epochEnable: 'False'
    frequencyEnable: 'True'
    meterLanDstID: '0'
    meterLanSrcID: '0'
    packetLengthFilter: '0x00'
    packetTypeFilter: '0x55'
    timestampEnable: 'True'
  states: {}
- name: smart_meters_google_earth_0
  id: smart_meters_google_earth
  parameters:
    file_save: ./smart_meters.kml
  states: {}
- name: smart_meters_google_map_0
  id: smart_meters_google_map
  parameters:
    API_Key: ''''''
    Start_Lat: '33.179569'
    Start_Lon: '-96.698914'
    Start_Zoom: '18'
    file_save: ./smart_meters.html
  states: {}

connections:
- [sandia_utils_file_source_0, out, smart_meters_Deframer_0, pdu_in]
- [smart_meters_Deframer_0, pdu_out, smart_meters_GridStream_0, pdu_in]
- [smart_meters_GridStream_0, pdu_out, smart_meters_google_earth_0, pdu_in]
- [smart_meters_GridStream_0, pdu_out, smart_meters_google_map_0, pdu_in]

metadata:
  file_format: 1
