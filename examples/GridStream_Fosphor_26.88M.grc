options:
  parameters:
    author: Hash
    description: GridStream Flowgraph built from J. Gilbert FHSS Reference Flowgraph
    generate_options: qt_gui
    id: GridStream_Fosphor
    output_language: python
    title: GridStream Detection Flowgraph
  states: {}

blocks:
- name: dec_att
  id: variable
  parameters:
    value: '20'
  states: {}
- name: dec_fc
  id: variable
  parameters:
    value: samp_rate / (decimation / 2.0)
  states: {}
- name: dec_fs
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: dec_twidth
  id: variable
  parameters:
    value: samp_rate / (decimation/2.0) * 0.1
  states: {}
- name: decim_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, dec_fs, dec_fc - dec_twidth / 2.0, dec_twidth, dec_att)
  states: {}
- name: fir_att
  id: variable
  parameters:
    value: '20'
  states: {}
- name: fir_fc
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: fir_fs
  id: variable
  parameters:
    comment: '|----------------------TAGGED BURST to PDU and PDU FIR FILTER CONFIG -----------------------|'
    value: samp_rate / (decimation/2.0)
  states: {}
- name: fir_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 1, fir_fc - fir_twidth/2.0, fir_twidth, fir_att)
  states: {}
- name: fir_twidth
  id: variable
  parameters:
    value: '0.025'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: gridstream_syncwords
  id: variable
  parameters:
    value: '''101010101010101000000000010111111111,1010101010101010000000000111111111111'''
  states: {}
- name: len_dt
  id: variable
  parameters:
    value: len(decim_taps)
  states: {}
- name: len_ft
  id: variable
  parameters:
    value: len(fir_taps)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/filename.cf32
    type: complex
  states: {state: disabled}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: /home/hash/SDR/Raw Captures/SigMF_Capture_11-29-2022.sigmf-data
    repeat: 'False'
    type: complex float (fc32_le)
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    comment: 'QT Widget: Throttle Factor'
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: burst_width
  id: parameter
  parameters:
    hide: part
    label: Burst Width
    short_id: W
    type: intx
    value: int(50e3)
  states: {}
- name: bw_max
  id: parameter
  parameters:
    hide: part
    label: Max Valid Bandwidth
    short_id: B
    type: eng_float
    value: '0'
  states: {}
- name: bw_min
  id: parameter
  parameters:
    hide: part
    label: Min Valid Bandwidth
    short_id: b
    type: eng_float
    value: '0'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: Frequency
    short_id: f
    type: eng_float
    value: 915e6
  states: {}
- name: cfe_snr
  id: parameter
  parameters:
    label: Center Frequency Estimator SNR
    short_id: c
    type: eng_float
    value: '6'
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    short_id: d
    type: intx
    value: '250'
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: FFT Size
    short_id: N
    type: intx
    value: int(2688/2)
  states: {}
- name: fhss_utils_cf_estimate_0
  id: fhss_utils_cf_estimate
  parameters:
    channel_freqs: '[]'
    method: fhss_utils.MIDDLE_OUT
    snr_min: cfe_snr
    thresh_min: '-25.0 - cfe_snr'
  states: {}
- name: fhss_utils_fft_burst_tagger_0
  id: fhss_utils_fft_burst_tagger
  parameters:
    burst_post_len: int(round((float(samp_rate)/fft_size)*post_burst_time))
    burst_pre_len: int(round((float(samp_rate)/fft_size)*pre_burst_time))
    burst_width: burst_width
    center_frequency: center_freq
    debug: 'False'
    fft_size: fft_size
    history_size: int(round((float(samp_rate)/fft_size)*hist_time))
    lookahead: int(round((float(samp_rate)/fft_size)*lookahead_time))
    max_burst_len: '0'
    max_bursts: '0'
    minoutbuf: 1024*1000*0
    preload_nf: '0'
    preload_nf_bool: 'False'
    sample_rate: samp_rate
    threshold: threshold
  states: {}
- name: fhss_utils_tagged_burst_to_pdu_0
  id: fhss_utils_tagged_burst_to_pdu
  parameters:
    decimation: int(decimation/2)
    max_burst_time: max_burst_time
    min_burst_time: min_burst_time
    relative_center_frequency: '0.0'
    relative_sample_rate: '1.0'
    relative_span: '1.0'
    sample_rate: samp_rate
    taps: decim_taps
    threads: '1'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
  states: {}
- name: freq_max
  id: parameter
  parameters:
    hide: part
    label: Maximum Frequency
    short_id: Q
    type: eng_float
    value: '0'
  states: {}
- name: freq_min
  id: parameter
  parameters:
    hide: part
    label: Minimum Frequency
    short_id: q
    type: eng_float
    value: '0'
  states: {}
- name: hist_time
  id: parameter
  parameters:
    hide: part
    label: Noise Estimate History (s)
    short_id: H
    type: eng_float
    value: '0.004'
  states: {}
- name: infile
  id: parameter
  parameters:
    label: Input SigMF Data File Name
    short_id: i
    type: str
    value: /tmp/data.sigmf-data
  states: {}
- name: lookahead_time
  id: parameter
  parameters:
    hide: part
    label: Lookahead Time [s]
    short_id: L
    type: eng_float
    value: '0.001'
  states: {}
- name: max_burst_time
  id: parameter
  parameters:
    hide: part
    label: Max Burst Time [s]
    short_id: M
    type: eng_float
    value: '0.6'
  states: {}
- name: min_burst_time
  id: parameter
  parameters:
    hide: part
    label: Min Burst Time [s]
    short_id: m
    type: eng_float
    value: '0.001'
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      .                                                                    |------------ INPUT/OUTPUT CONFIGURATION  -----------|                  |-------------------------- CORE DETECTOR CONFIGURATION -------------------------------|                      |------------- BURST BOUNDARY CONFIGURATION ----------------|

      --------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
      .                                                                                                                                                                                                                                  Input
    note: SECTION
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      .                                   |------------ ENABLE THESE BLOCKS TO PLAYBACK FROM A FILE  -----------|                                     |-------------------------- ENABLE THESE BLOCKS TO USE USRP B200 -------------------------------|                      |------- ENABLE THIS BLOCK TO CAPTURE DATA TO FILE ----------|

      --------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
                                                                                                                                                                                                                                                Burst Detection
    note: SECTION
  states: {}
- name: note_0_1
  id: note
  parameters:
    comment: |-
      ---------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
      .                                                                                                                                                                                                                                  FM Demod and Symbol Recovery
    note: SECTION
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    comment: '---------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------'
    note: SECTION
  states: {}
- name: note_0_1_0_0
  id: note
  parameters:
    comment: |-
      ---------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
      .                                                                                                                                                                                                                                  Align and Decode Bursts
    note: SECTION
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      The blocks here are also
      available  wrapped up in
      a python hier block
    note: README
  states: {}
- name: outfile
  id: parameter
  parameters:
    label: Output SigMF Meta File Name
    short_id: o
    type: str
    value: ''''''
  states: {}
- name: parameter_0
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: pdu_utils_message_counter_0
  id: pdu_utils_message_counter
  parameters:
    name: GridStream CRC
  states: {}
- name: pdu_utils_message_counter_0_0
  id: pdu_utils_message_counter
  parameters:
    name: GridStream Sync
  states: {}
- name: pdu_utils_pdu_align_0
  id: pdu_utils_pdu_align
  parameters:
    match_mode: pdu_utils.ALIGN_FIRST_MATCH
    mode: pdu_utils.ALIGN_DROP
    offset: '-20'
    syncwords: gridstream_syncwords
    threshold: '0'
  states: {}
- name: pdu_utils_pdu_clock_recovery_0_0
  id: pdu_utils_pdu_clock_recovery
  parameters:
    binary_slice: binary
    debug: 'False'
    win_type: pdu_utils.GAUSSIAN_WIN
  states: {}
- name: pdu_utils_pdu_fine_time_measure_0
  id: pdu_utils_pdu_fine_time_measure
  parameters:
    average_width: '10'
    buffer_percent: '15'
    post_burst_time: post_burst_time
    pre_burst_time: pre_burst_time
  states: {}
- name: pdu_utils_pdu_fir_filter_1
  id: pdu_utils_pdu_fir_filter
  parameters:
    decimation: '2'
    taps: fir_taps
  states: {}
- name: pdu_utils_pdu_quadrature_demod_cf_0
  id: pdu_utils_pdu_quadrature_demod_cf
  parameters:
    sensitivity: '1.0'
  states: {}
- name: post_burst_time
  id: parameter
  parameters:
    hide: part
    label: Post Burst Time [s]
    short_id: P
    type: eng_float
    value: '0.00008'
  states: {}
- name: pre_burst_time
  id: parameter
  parameters:
    hide: part
    label: Pre Burst Time [s]
    short_id: p
    type: eng_float
    value: '0.00008'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: r
    type: intx
    value: int(26.88e6)
  states: {}
- name: sandia_utils_file_sink_0
  id: sandia_utils_file_sink
  parameters:
    align: 'True'
    create_new_dir: 'False'
    debug: 'False'
    directory: '"/home/hash/SDR/gr-smart_meters/examples"'
    file_num_rollover: '0'
    file_type: raw_header
    mode: sandia_utils.MANUAL
    name_spec: '"Save_PDUs_to_File_for_Playback.dat"'
    nsamples: '0'
    rate: int(samp_rate)
    record: 'True'
    type: message
    vlen: '1'
  states: {state: disabled}
- name: short_in
  id: parameter
  parameters:
    label: SC16 Input
    short_id: s
    type: intx
    value: '1'
  states: {}
- name: sigmf_label
  id: parameter
  parameters:
    hide: part
    label: SigMF Label
    short_id: l
    type: str
    value: '''radio1'''
  states: {}
- name: sigmf_utils_pdu_meta_writer_0
  id: sigmf_utils_pdu_meta_writer
  parameters:
    dtype: cf32_le
    filename: /home/hash/SDR/Raw Captures/SigMF_Capture_12-03-2022.sigmf-meta
    freq: center_freq
    label: '''radio'''
    rate: samp_rate
  states: {state: disabled}
- name: sigmf_utils_tag_meta_writer_0
  id: sigmf_utils_tag_meta_writer
  parameters:
    dtype: cf32_le
    filename: /home/hash/SDR/Raw Captures/SigMF_GetMeterRead_12-4-2022.sigmf-meta
    freq: center_freq
    label: use_burst_id
    rate: samp_rate
  states: {state: disabled}
- name: smart_meters_Deframer_0
  id: smart_meters_Deframer
  parameters:
    debug: 'False'
    max_length: '300'
    min_length: '6'
  states: {}
- name: smart_meters_GridStream_0
  id: smart_meters_GridStream
  parameters:
    baudrateEnable: 'False'
    crcEnable: 'False'
    crcInitialValue: '0x5FD6'
    debugEnable: 'True'
    epochEnable: 'False'
    frequencyEnable: 'False'
    meterLanDstID: '0x00'
    meterLanSrcID: '0x00'
    packetLengthFilter: '0x00'
    packetTypeFilter: '0x00'
    timestampEnable: 'True'
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    bandwidth0: 26.88e6
    center_freq0: center_freq
    dc_removal0: 'False'
    dev_args: '"num_recv_frames=1024"'
    driver: bladerf
    gain0: gain
    minoutbuf: 2048*1000
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Threshold (dB)
    short_id: t
    type: eng_float
    value: '8'
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_args: '"num_recv_frames=1024"'
    gain0: gain
    minoutbuf: 2048*1000*0
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: input
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: bursts
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: hard_syms
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: input
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: bursts
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: hard_syms
  states: {}

connections:
- [blocks_sigmf_source_minimal_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0_0, '0', virtual_sink_0_1, '0']
- [fhss_utils_cf_estimate_0, out, pdu_utils_pdu_fir_filter_1, pdu_in]
- [fhss_utils_fft_burst_tagger_0, '0', fhss_utils_tagged_burst_to_pdu_0, '0']
- [fhss_utils_fft_burst_tagger_0, '0', sigmf_utils_tag_meta_writer_0, '0']
- [fhss_utils_tagged_burst_to_pdu_0, cpdus, fhss_utils_cf_estimate_0, in]
- [pdu_utils_pdu_align_0, pdu_out, pdu_utils_message_counter_0_0, msg]
- [pdu_utils_pdu_align_0, pdu_out, sandia_utils_file_sink_0, in]
- [pdu_utils_pdu_align_0, pdu_out, smart_meters_Deframer_0, pdu_in]
- [pdu_utils_pdu_clock_recovery_0_0, pdu_out, sigmf_utils_pdu_meta_writer_0, in]
- [pdu_utils_pdu_clock_recovery_0_0, pdu_out, virtual_sink_0_0_0, '0']
- [pdu_utils_pdu_fine_time_measure_0, pdu_out, virtual_sink_0_0, '0']
- [pdu_utils_pdu_fir_filter_1, pdu_out, pdu_utils_pdu_fine_time_measure_0, pdu_in]
- [pdu_utils_pdu_quadrature_demod_cf_0, fpdus, pdu_utils_pdu_clock_recovery_0_0, pdu_in]
- [smart_meters_Deframer_0, pdu_out, smart_meters_GridStream_0, pdu_in]
- [smart_meters_GridStream_0, pdu_out, pdu_utils_message_counter_0, msg]
- [soapy_custom_source_0, '0', blocks_file_sink_0, '0']
- [soapy_custom_source_0, '0', virtual_sink_0, '0']
- [uhd_usrp_source_1, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_1, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', fhss_utils_fft_burst_tagger_0, '0']
- [virtual_source_0, '0', fosphor_qt_sink_c_0, '0']
- [virtual_source_0_2, '0', pdu_utils_pdu_quadrature_demod_cf_0, cpdus]
- [virtual_source_0_2_0, '0', pdu_utils_pdu_align_0, pdu_in]

metadata:
  file_format: 1
