options:
  parameters:
    author: hash
    generate_options: no_gui
    id: pdu_playback
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: sandia_utils_file_source_0
  id: sandia_utils_file_source
  parameters:
    begin_tag: pmt.PMT_NIL
    file: /home/hash/SDR/gr-smart_meters/examples/SigMF_Capture_11-29-2022.dat
    file_tags: 'False'
    file_type: message
    force_new: 'False'
    msg_period_ms: '10'
    queue_depth: '100'
    rate: int(samp_rate)
    repeat: 'False'
    type: complex
    vlen: '1'
  states: {}
- name: smart_meters_Deframer_0
  id: smart_meters_Deframer
  parameters:
    debug: 'False'
    max_length: '300'
    min_length: '5'
  states: {}
- name: smart_meters_GridStream_0
  id: smart_meters_GridStream
  parameters:
    baudrateEnable: 'False'
    crcEnable: 'False'
    crcInitialValue: '0x5FD6'
    debugEnable: 'True'
    epochEnable: 'False'
    frequencyEnable: 'False'
    meterLanDstID: '0'
    meterLanSrcID: '0'
    packetLengthFilter: '0x00'
    packetTypeFilter: '0x00'
    timestampEnable: 'False'
  states: {}

connections:
- [sandia_utils_file_source_0, out, smart_meters_Deframer_0, pdu_in]
- [smart_meters_Deframer_0, pdu_out, blocks_message_debug_0, print]
- [smart_meters_Deframer_0, pdu_out, smart_meters_GridStream_0, pdu_in]

metadata:
  file_format: 1
